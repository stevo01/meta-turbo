COMPATIBLE_MACHINE = "raspberrypi3-64"
INSANE_SKIP_${PN} = "ldflags"