COMPATIBLE_MACHINE = "raspberrypi3-64"
